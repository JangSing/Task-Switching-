# Keil uVision project AssemblyC.uvprojx, settings and files
target workspace (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AssemblyC
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\STM32Cube_FW_F4_V1.5.0\Drivers\STM32F4xx_HAL_Driver\Src;..\STM32Cube_FW_F4_V1.5.0\Drivers\STM32F4xx_HAL_Driver\Inc;.\src;..\STM32Cube_FW_F4_V1.5.0\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group C
    ./src/: Main.c TCB.c TCB.h LinkedList.c LinkedList.h
  group Assembly
    ./src/: startup_stm32f429xx.s SaveRegister.s SaveRegister.h TaskSwitch.h TaskSwitch.s
  group Peripherals
    ./Config/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_rcc.h stm32f4xx_hal_def.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h
    ./Config/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c
  group Core
    ./src/: stm32f4xx_it.h stm32f4xx_it.c stm32f4xx.h stm32f429xx.h system_stm32f4xx.c system_stm32f4xx.h stm32f4xx_hal_conf.h
    ./00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Include/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
